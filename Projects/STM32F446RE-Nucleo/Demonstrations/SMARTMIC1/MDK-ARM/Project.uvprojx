# Keil uVision project Project.uvprojx, settings and files
target STM32F446-Nucleo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IROM(0x08000000-0x807FFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Project +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __FPU_PRESENT=1U,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO,STM32F446xx,ARM_MATH_CM4,NUCLEOF446_DEMO
  c include: ../Inc;../../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Inc;../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../../../../../Middlewares/ST/STCmdP/inc;../../../../../Middlewares/ST/STM32_AcousticBF_Library/Inc;../../../../../Middlewares/ST/STM32_AcousticEC_Library/Inc;../../../../../Middlewares/ST/STM32_AcousticSL_Library/Inc;../../../../../Middlewares/ST/STM32_AcousticDB_Library/Inc;../../../../../Drivers/BSP/CCA01M1;../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../../../../../Drivers/BSP/STM32F4xx-Nucleo;../../../../../Drivers/BSP/CCA02M2;../../../../../Drivers/BSP/Components/Common;../../../../../Drivers/BSP/Components/sta350bw
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f446xx.s
  group Application/Patch
    ../Patch/: stm32f4xx_hal_pcd_patch.c
  group Application/User
    ../Src/: audio_application.c Audio_SerialCmd_Handlers.c main.c nucleo_f446re_bus.c STCmdP_interpreter.c stm32f4xx_it.c UART_protocol_interface.c usbd_audio_if.c usbd_conf.c usbd_desc.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/CCA01M1
    ../../../../../Drivers/BSP/CCA01M1/: cca01m1_audio.c
  group Drivers/BSP/CCA02M2
    ../../../../../Drivers/BSP/CCA02M2/: cca02m2_audio.c
  group Drivers/BSP/Components/STA350BW
    ../../../../../Drivers/BSP/Components/sta350bw/: sta350bw.c sta350bw_reg.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c stm32f4xx_nucleo_USART.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usb.c
  group Middlewares/ST/STCmdP
    ../../../../../Middlewares/ST/STCmdP/src/: STCmdP.c
  group Middlewares/ST/STM32_Audio/AEC
    ../../../../../Middlewares/ST/STM32_AcousticEC_Library/Src/: acousticEC.c echo.c Echo_library.c filterbank.c preprocess.c smallft.c
  group Middlewares/ST/STM32_Audio/BEAMFORMING
    ../../../../../Middlewares/ST/STM32_AcousticBF_Library/Src/: acousticBF.c
  group Middlewares/ST/STM32_Audio/dBSPL
    ../../../../../Middlewares/ST/STM32_AcousticDB_Library/Lib/: Acoustic_DB100.c
  group Middlewares/ST/STM32_Audio/PDM
    ../../../../../Middlewares/ST/STM32_Audio/Addons/PDM/Lib/: libPDMFilter_CM4_Keil_wc16.lib
  group Middlewares/ST/STM32_Audio/SOURCELOC
    ../../../../../Middlewares/ST/STM32_AcousticSL_Library/Src/: AcousticSL.c
  group Middlewares/STM32_USBD_Library/Class/Audio
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio_in.c
  group Middlewares/STM32_USBD_Library/Core
    ../../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
